## kernel/uifirst/Kconfig
```kconfig
config OPLUS_FEATURE_UIFIRST
	tristate "uifirst"
	default y
	help
	  turning sched for ui, render and so on to improve UX
```
